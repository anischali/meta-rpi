include kernel-configs.inc