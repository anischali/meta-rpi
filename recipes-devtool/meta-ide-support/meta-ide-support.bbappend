DEPENDS:append = " bison-native flex-native"
